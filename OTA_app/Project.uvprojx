# Keil uVision project Project.uvprojx, settings and files
target Target_1 (5050106::V5.05 update 1 (build 106)::ARMCC)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.1.0.5
  cpu: IRAM(0x20000000,0x5000) IROM(0x08000000,0x10000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: Project +hex
  AfterMake: $K\ARM\ARMCC\bin\fromelf.exe --bin -o "$P\Output\@L.bin" "!L"
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=3 v6LangP=3 wLevel=2
  c define: USE_STDPERIPH_DRIVER
  c misc: --no-multibyte-chars
  c include: .\Start;.\User;.\Lib;.\System;.\Hardware
  library: MicroLIB
  memory RVCT4: ROM 0x8004400 size 0xb800
  memory RVCT9: RAM 0x20000000 size 0x5000
  group Start
    ./Start/: startup_stm32f10x_md.s core_cm3.h stm32f10x.h system_stm32f10x.h core_cm3.c system_stm32f10x.c
  group Lib
    ./Lib/: misc.c misc.h stm32f10x_adc.c stm32f10x_adc.h stm32f10x_bkp.c stm32f10x_bkp.h stm32f10x_can.c stm32f10x_can.h stm32f10x_cec.c stm32f10x_cec.h stm32f10x_crc.c stm32f10x_crc.h stm32f10x_dac.c stm32f10x_dac.h stm32f10x_dbgmcu.c stm32f10x_dbgmcu.h stm32f10x_dma.c stm32f10x_dma.h stm32f10x_exti.c stm32f10x_exti.h stm32f10x_flash.c stm32f10x_flash.h stm32f10x_fsmc.c stm32f10x_fsmc.h stm32f10x_gpio.c stm32f10x_gpio.h stm32f10x_i2c.c stm32f10x_i2c.h stm32f10x_iwdg.c stm32f10x_iwdg.h stm32f10x_pwr.c stm32f10x_pwr.h stm32f10x_rcc.c stm32f10x_rcc.h stm32f10x_rtc.c stm32f10x_rtc.h stm32f10x_sdio.c stm32f10x_sdio.h stm32f10x_spi.c stm32f10x_spi.h stm32f10x_tim.c stm32f10x_tim.h stm32f10x_usart.c stm32f10x_usart.h stm32f10x_wwdg.c stm32f10x_wwdg.h
  group User
    ./User/: main.c stm32f10x_conf.h stm32f10x_it.c stm32f10x_it.h ota_config.h ota_flash.c ota_flash.h ota_app.c ota_app.h
  group System
    ./System/: Tim.c Tim.h sys.c sys.h generic.c generic.h
  group Hardware
    ./Hardware/: LED.c LED.h OLED.c OLED.h OLED_Font.h KEY.c KEY.h CountSensor.c CountSensor.h PWM.c PWM.h Encoder.c Encoder.h Serial.c Serial.h iic.c iic.h MPU6050.h MPU6050_Reg.h MPU6050.c MySPI.c MySPI.h W25Q64_Ins.h W25Q64.h W25Q64.c menu.c menu.h DMA.c DMA.h Picture.h oledfont.h mylcd.c mylcd.h crc32.c crc32.h ota_log.c ota_log.h ota_uart.c ota_uart.h
